* Title: "initialization"

.ic
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_0__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_1__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_2__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_3__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_4__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_5__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_6__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_7__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_8__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_9__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_10__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_11__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_12__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_13__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_14__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_15__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_16__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_17__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_18__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_19__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_20__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_21__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_22__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_23__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_24__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_25__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_26__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_27__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_28__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_29__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_30__w.XU.Q = 0
+ xmem_pipeline.Xmem_top.Xarray_0.Xword_31__w.XU.Q = 0

$ Spice netlist generated by v2lvs
$ v2011.3_18.12    Wed Aug 10 15:08:50 PDT 2011
.INCLUDE "/home/wjin/lincx/library/spice/cmn65gp_mvt_stdcells_mac.sp"

.SUBCKT decoder WEN A[5] A[4] A[3] A[2] A[1] A[0] wwl[63] wwl[62] wwl[61]
+ wwl[60] wwl[59] wwl[58] wwl[57] wwl[56] wwl[55] wwl[54] wwl[53] wwl[52]
+ wwl[51] wwl[50] wwl[49] wwl[48] wwl[47] wwl[46] wwl[45] wwl[44] wwl[43]
+ wwl[42] wwl[41] wwl[40] wwl[39] wwl[38] wwl[37] wwl[36] wwl[35] wwl[34]
+ wwl[33] wwl[32] wwl[31] wwl[30] wwl[29] wwl[28] wwl[27] wwl[26] wwl[25]
+ wwl[24] wwl[23] wwl[22] wwl[21] wwl[20] wwl[19] wwl[18] wwl[17] wwl[16]
+ wwl[15] wwl[14] wwl[13] wwl[12] wwl[11] wwl[10] wwl[9] wwl[8] wwl[7] wwl[6]
+ wwl[5] wwl[4] wwl[3] wwl[2] wwl[1] wwl[0] rwl[31] rwl[30] rwl[29] rwl[28]
+ rwl[27] rwl[26] rwl[25] rwl[24] rwl[23] rwl[22] rwl[21] rwl[20] rwl[19]
+ rwl[18] rwl[17] rwl[16] rwl[15] rwl[14] rwl[13] rwl[12] rwl[11] rwl[10]
+ rwl[9] rwl[8] rwl[7] rwl[6] rwl[5] rwl[4] rwl[3] rwl[2] rwl[1] rwl[0]
+ rwlb[31] rwlb[30] rwlb[29] rwlb[28] rwlb[27] rwlb[26] rwlb[25] rwlb[24]
+ rwlb[23] rwlb[22] rwlb[21] rwlb[20] rwlb[19] rwlb[18] rwlb[17] rwlb[16]
+ rwlb[15] rwlb[14] rwlb[13] rwlb[12] rwlb[11] rwlb[10] rwlb[9] rwlb[8] rwlb[7]
+ rwlb[6] rwlb[5] rwlb[4] rwlb[3] rwlb[2] rwlb[1] rwlb[0]
XU71 n76 n37 rwlb[31] VDD VSS ND2D1LVT
XU72 n77 n37 rwlb[30] VDD VSS ND2D1LVT
XU73 n78 n79 n58 VDD VSS ND2D1LVT
XU74 n76 n36 rwlb[29] VDD VSS ND2D1LVT
XU75 n77 n36 rwlb[28] VDD VSS ND2D1LVT
XU76 n80 n78 n61 VDD VSS ND2D1LVT
XU77 n76 n35 rwlb[27] VDD VSS ND2D1LVT
XU78 n77 n35 rwlb[26] VDD VSS ND2D1LVT
XU79 n81 n78 n63 VDD VSS ND2D1LVT
XU80 n76 n34 rwlb[25] VDD VSS ND2D1LVT
XU81 n77 n34 rwlb[24] VDD VSS ND2D1LVT
XU82 n78 n82 n64 VDD VSS ND2D1LVT
XU83 A[4] A[3] n78 VDD VSS AN2XD1LVT
XU84 n76 n41 rwlb[23] VDD VSS ND2D1LVT
XU85 n77 n41 rwlb[22] VDD VSS ND2D1LVT
XU86 n83 n79 n65 VDD VSS ND2D1LVT
XU87 n76 n40 rwlb[21] VDD VSS ND2D1LVT
XU88 n77 n40 rwlb[20] VDD VSS ND2D1LVT
XU89 n83 n80 n66 VDD VSS ND2D1LVT
XU90 n76 n39 rwlb[19] VDD VSS ND2D1LVT
XU91 n77 n39 rwlb[18] VDD VSS ND2D1LVT
XU92 n83 n81 n67 VDD VSS ND2D1LVT
XU93 n76 n38 rwlb[17] VDD VSS ND2D1LVT
XU94 n77 n38 rwlb[16] VDD VSS ND2D1LVT
XU95 n83 n82 n68 VDD VSS ND2D1LVT
XU96 A[4] n50 n83 VDD VSS AN2XD1LVT
XU97 n76 n45 rwlb[15] VDD VSS ND2D1LVT
XU98 n77 n45 rwlb[14] VDD VSS ND2D1LVT
XU99 n79 n84 n69 VDD VSS ND2D1LVT
XU100 n76 n44 rwlb[13] VDD VSS ND2D1LVT
XU101 n77 n44 rwlb[12] VDD VSS ND2D1LVT
XU102 n80 n84 n70 VDD VSS ND2D1LVT
XU103 n76 n43 rwlb[11] VDD VSS ND2D1LVT
XU104 n77 n43 rwlb[10] VDD VSS ND2D1LVT
XU105 n81 n84 n71 VDD VSS ND2D1LVT
XU106 n76 n42 rwlb[9] VDD VSS ND2D1LVT
XU107 n77 n42 rwlb[8] VDD VSS ND2D1LVT
XU108 n84 n82 n54 VDD VSS ND2D1LVT
XU110 n76 n49 rwlb[7] VDD VSS ND2D1LVT
XU111 n77 n49 rwlb[6] VDD VSS ND2D1LVT
XU112 n85 n79 n57 VDD VSS ND2D1LVT
XU114 n76 n48 rwlb[5] VDD VSS ND2D1LVT
XU115 n77 n48 rwlb[4] VDD VSS ND2D1LVT
XU116 n80 n85 n62 VDD VSS ND2D1LVT
XU118 n76 n47 rwlb[3] VDD VSS ND2D1LVT
XU119 n77 n47 rwlb[2] VDD VSS ND2D1LVT
XU120 n81 n85 n72 VDD VSS ND2D1LVT
XU122 n76 n46 rwlb[1] VDD VSS ND2D1LVT
XU124 n77 n46 rwlb[0] VDD VSS ND2D1LVT
XU125 n85 n82 n73 VDD VSS ND2D1LVT
XU129 rwlb[1] rwl[1] VDD VSS INVD1LVT
XU130 rwlb[3] rwl[3] VDD VSS INVD1LVT
XU131 rwlb[5] rwl[5] VDD VSS INVD1LVT
XU132 rwlb[7] rwl[7] VDD VSS INVD1LVT
XU133 rwlb[9] rwl[9] VDD VSS INVD1LVT
XU134 rwlb[11] rwl[11] VDD VSS INVD1LVT
XU135 rwlb[13] rwl[13] VDD VSS INVD1LVT
XU136 rwlb[15] rwl[15] VDD VSS INVD1LVT
XU137 rwlb[17] rwl[17] VDD VSS INVD1LVT
XU138 rwlb[19] rwl[19] VDD VSS INVD1LVT
XU139 rwlb[21] rwl[21] VDD VSS INVD1LVT
XU140 rwlb[23] rwl[23] VDD VSS INVD1LVT
XU141 rwlb[25] rwl[25] VDD VSS INVD1LVT
XU142 rwlb[27] rwl[27] VDD VSS INVD1LVT
XU143 rwlb[29] rwl[29] VDD VSS INVD1LVT
XU144 rwlb[31] rwl[31] VDD VSS INVD1LVT
XU145 rwlb[0] rwl[0] VDD VSS INVD1LVT
XU146 rwlb[2] rwl[2] VDD VSS INVD1LVT
XU147 rwlb[4] rwl[4] VDD VSS INVD1LVT
XU148 rwlb[6] rwl[6] VDD VSS INVD1LVT
XU149 rwlb[8] rwl[8] VDD VSS INVD1LVT
XU150 rwlb[10] rwl[10] VDD VSS INVD1LVT
XU151 rwlb[12] rwl[12] VDD VSS INVD1LVT
XU152 rwlb[14] rwl[14] VDD VSS INVD1LVT
XU153 rwlb[16] rwl[16] VDD VSS INVD1LVT
XU154 rwlb[18] rwl[18] VDD VSS INVD1LVT
XU155 rwlb[20] rwl[20] VDD VSS INVD1LVT
XU156 rwlb[22] rwl[22] VDD VSS INVD1LVT
XU157 rwlb[24] rwl[24] VDD VSS INVD1LVT
XU158 rwlb[26] rwl[26] VDD VSS INVD1LVT
XU159 rwlb[28] rwl[28] VDD VSS INVD1LVT
XU160 rwlb[30] rwl[30] VDD VSS INVD1LVT
XU161 A[5] n33 VDD VSS INVD1LVT
XU162 n64 n34 VDD VSS INVD1LVT
XU163 n63 n35 VDD VSS INVD1LVT
XU164 n61 n36 VDD VSS INVD1LVT
XU165 n58 n37 VDD VSS INVD1LVT
XU166 n68 n38 VDD VSS INVD1LVT
XU167 n67 n39 VDD VSS INVD1LVT
XU168 n66 n40 VDD VSS INVD1LVT
XU169 n65 n41 VDD VSS INVD1LVT
XU170 n54 n42 VDD VSS INVD1LVT
XU171 n71 n43 VDD VSS INVD1LVT
XU172 n70 n44 VDD VSS INVD1LVT
XU173 n69 n45 VDD VSS INVD1LVT
XU174 n73 n46 VDD VSS INVD1LVT
XU175 n72 n47 VDD VSS INVD1LVT
XU176 n62 n48 VDD VSS INVD1LVT
XU177 n57 n49 VDD VSS INVD1LVT
XU178 A[3] n50 VDD VSS INVD1LVT
XU179 A[2] n51 VDD VSS INVD1LVT
XU180 A[1] n52 VDD VSS INVD1LVT
XU181 A[0] n53 VDD VSS INVD1LVT
XU1 n60 n73 wwl[32] VDD VSS NR2XD0LVT
XU2 n60 n72 wwl[34] VDD VSS NR2XD0LVT
XU3 n60 n62 wwl[36] VDD VSS NR2XD0LVT
XU4 n60 n71 wwl[42] VDD VSS NR2XD0LVT
XU5 n60 n70 wwl[44] VDD VSS NR2XD0LVT
XU6 n60 n69 wwl[46] VDD VSS NR2XD0LVT
XU7 n60 n68 wwl[48] VDD VSS NR2XD0LVT
XU8 n60 n67 wwl[50] VDD VSS NR2XD0LVT
XU9 n60 n66 wwl[52] VDD VSS NR2XD0LVT
XU10 n60 n65 wwl[54] VDD VSS NR2XD0LVT
XU11 n60 n64 wwl[56] VDD VSS NR2XD0LVT
XU12 n60 n63 wwl[58] VDD VSS NR2XD0LVT
XU13 n60 n61 wwl[60] VDD VSS NR2XD0LVT
XU14 n56 n73 wwl[0] VDD VSS NR2XD0LVT
XU15 n56 n72 wwl[2] VDD VSS NR2XD0LVT
XU16 n56 n62 wwl[4] VDD VSS NR2XD0LVT
XU17 n56 n57 wwl[6] VDD VSS NR2XD0LVT
XU18 n56 n71 wwl[10] VDD VSS NR2XD0LVT
XU19 n56 n70 wwl[12] VDD VSS NR2XD0LVT
XU20 n56 n69 wwl[14] VDD VSS NR2XD0LVT
XU21 n56 n68 wwl[16] VDD VSS NR2XD0LVT
XU22 n56 n67 wwl[18] VDD VSS NR2XD0LVT
XU23 n56 n66 wwl[20] VDD VSS NR2XD0LVT
XU24 n56 n65 wwl[22] VDD VSS NR2XD0LVT
XU25 n56 n64 wwl[24] VDD VSS NR2XD0LVT
XU26 n56 n63 wwl[26] VDD VSS NR2XD0LVT
XU27 n56 n61 wwl[28] VDD VSS NR2XD0LVT
XU28 n56 n58 wwl[30] VDD VSS NR2XD0LVT
XU29 n57 n60 wwl[38] VDD VSS NR2XD0LVT
XU30 n54 n60 wwl[40] VDD VSS NR2XD0LVT
XU31 n58 n60 wwl[62] VDD VSS NR2XD0LVT
XU32 n54 n56 wwl[8] VDD VSS NR2XD0LVT
XU33 n74 n53 n60 VDD VSS ND2D1LVT
XU34 n75 n53 n56 VDD VSS ND2D1LVT
XU35 n51 n52 n79 VDD VSS NR2XD0LVT
XU36 n55 n73 wwl[1] VDD VSS NR2XD0LVT
XU37 n55 n72 wwl[3] VDD VSS NR2XD0LVT
XU38 n55 n62 wwl[5] VDD VSS NR2XD0LVT
XU39 n55 n57 wwl[7] VDD VSS NR2XD0LVT
XU40 n55 n71 wwl[11] VDD VSS NR2XD0LVT
XU41 n55 n70 wwl[13] VDD VSS NR2XD0LVT
XU42 n55 n69 wwl[15] VDD VSS NR2XD0LVT
XU43 n55 n68 wwl[17] VDD VSS NR2XD0LVT
XU44 n55 n67 wwl[19] VDD VSS NR2XD0LVT
XU45 n55 n66 wwl[21] VDD VSS NR2XD0LVT
XU46 n55 n65 wwl[23] VDD VSS NR2XD0LVT
XU47 n55 n64 wwl[25] VDD VSS NR2XD0LVT
XU48 n55 n63 wwl[27] VDD VSS NR2XD0LVT
XU49 n55 n61 wwl[29] VDD VSS NR2XD0LVT
XU50 n55 n58 wwl[31] VDD VSS NR2XD0LVT
XU51 n59 n73 wwl[33] VDD VSS NR2XD0LVT
XU52 n59 n72 wwl[35] VDD VSS NR2XD0LVT
XU53 n59 n62 wwl[37] VDD VSS NR2XD0LVT
XU54 n59 n71 wwl[43] VDD VSS NR2XD0LVT
XU55 n59 n70 wwl[45] VDD VSS NR2XD0LVT
XU56 n59 n69 wwl[47] VDD VSS NR2XD0LVT
XU57 n59 n68 wwl[49] VDD VSS NR2XD0LVT
XU58 n59 n67 wwl[51] VDD VSS NR2XD0LVT
XU59 n59 n66 wwl[53] VDD VSS NR2XD0LVT
XU60 n59 n65 wwl[55] VDD VSS NR2XD0LVT
XU61 n59 n64 wwl[57] VDD VSS NR2XD0LVT
XU62 n59 n63 wwl[59] VDD VSS NR2XD0LVT
XU63 n59 n61 wwl[61] VDD VSS NR2XD0LVT
XU64 n57 n59 wwl[39] VDD VSS NR2XD0LVT
XU65 n54 n59 wwl[41] VDD VSS NR2XD0LVT
XU66 n58 n59 wwl[63] VDD VSS NR2XD0LVT
XU67 n54 n55 wwl[9] VDD VSS NR2XD0LVT
XU68 n74 A[0] n59 VDD VSS ND2D1LVT
XU69 A[0] n75 n55 VDD VSS ND2D1LVT
XU70 A[5] WEN n75 VDD VSS NR2XD0LVT
XU109 n51 A[1] n80 VDD VSS NR2XD0LVT
XU113 n33 WEN n74 VDD VSS NR2XD0LVT
XU117 A[1] A[2] n82 VDD VSS NR2XD0LVT
XU121 A[3] A[4] n85 VDD VSS NR2XD0LVT
XU123 n50 A[4] n84 VDD VSS NR2XD0LVT
XU126 n52 A[2] n81 VDD VSS NR2XD0LVT
XU127 WEN A[0] n76 VDD VSS AN2XD1LVT
XU128 WEN n53 n77 VDD VSS AN2XD1LVT
.ENDS

.SUBCKT bitlines data[15] data[14] data[13] data[12] data[11] data[10] data[9]
+ data[8] data[7] data[6] data[5] data[4] data[3] data[2] data[1] data[0]
+ wbl[15] wbl[14] wbl[13] wbl[12] wbl[11] wbl[10] wbl[9] wbl[8] wbl[7] wbl[6]
+ wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0] wblb[15] wblb[14] wblb[13] wblb[12]
+ wblb[11] wblb[10] wblb[9] wblb[8] wblb[7] wblb[6] wblb[5] wblb[4] wblb[3]
+ wblb[2] wblb[1] wblb[0]
*.CONNECT wbl[15] data0[15]
*.CONNECT data0[15] data[15]
*.CONNECT wbl[14] data0[14]
*.CONNECT data0[14] data[14]
*.CONNECT wbl[13] data0[13]
*.CONNECT data0[13] data[13]
*.CONNECT wbl[12] data0[12]
*.CONNECT data0[12] data[12]
*.CONNECT wbl[11] data0[11]
*.CONNECT data0[11] data[11]
*.CONNECT wbl[10] data0[10]
*.CONNECT data0[10] data[10]
*.CONNECT wbl[9] data0[9]
*.CONNECT data0[9] data[9]
*.CONNECT wbl[8] data0[8]
*.CONNECT data0[8] data[8]
*.CONNECT wbl[7] data0[7]
*.CONNECT data0[7] data[7]
*.CONNECT wbl[6] data0[6]
*.CONNECT data0[6] data[6]
*.CONNECT wbl[5] data0[5]
*.CONNECT data0[5] data[5]
*.CONNECT wbl[4] data0[4]
*.CONNECT data0[4] data[4]
*.CONNECT wbl[3] data0[3]
*.CONNECT data0[3] data[3]
*.CONNECT wbl[2] data0[2]
*.CONNECT data0[2] data[2]
*.CONNECT wbl[1] data0[1]
*.CONNECT data0[1] data[1]
*.CONNECT wbl[0] data0[0]
*.CONNECT data0[0] data[0]
XU1 data[15] wblb[15] VDD VSS INVD1LVT
XU2 data[14] wblb[14] VDD VSS INVD1LVT
XU3 data[13] wblb[13] VDD VSS INVD1LVT
XU4 data[12] wblb[12] VDD VSS INVD1LVT
XU5 data[11] wblb[11] VDD VSS INVD1LVT
XU6 data[10] wblb[10] VDD VSS INVD1LVT
XU7 data[9] wblb[9] VDD VSS INVD1LVT
XU8 data[8] wblb[8] VDD VSS INVD1LVT
XU9 data[7] wblb[7] VDD VSS INVD1LVT
XU10 data[6] wblb[6] VDD VSS INVD1LVT
XU11 data[5] wblb[5] VDD VSS INVD1LVT
XU12 data[4] wblb[4] VDD VSS INVD1LVT
XU13 data[3] wblb[3] VDD VSS INVD1LVT
XU14 data[2] wblb[2] VDD VSS INVD1LVT
XU15 data[1] wblb[1] VDD VSS INVD1LVT
XU16 data[0] wblb[0] VDD VSS INVD1LVT
.ENDS

.SUBCKT word_0 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_33 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_34 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_35 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_36 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_37 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_38 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_39 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_40 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_41 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_42 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_43 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_44 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_45 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_46 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_47 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_48 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_49 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_50 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_51 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_52 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_53 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_54 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_55 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_56 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_57 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_58 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_59 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_60 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_61 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_62 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_63 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT array_0 wwl[31] wwl[30] wwl[29] wwl[28] wwl[27] wwl[26] wwl[25] wwl[24]
+ wwl[23] wwl[22] wwl[21] wwl[20] wwl[19] wwl[18] wwl[17] wwl[16] wwl[15]
+ wwl[14] wwl[13] wwl[12] wwl[11] wwl[10] wwl[9] wwl[8] wwl[7] wwl[6] wwl[5]
+ wwl[4] wwl[3] wwl[2] wwl[1] wwl[0] rwl[31] rwl[30] rwl[29] rwl[28] rwl[27]
+ rwl[26] rwl[25] rwl[24] rwl[23] rwl[22] rwl[21] rwl[20] rwl[19] rwl[18]
+ rwl[17] rwl[16] rwl[15] rwl[14] rwl[13] rwl[12] rwl[11] rwl[10] rwl[9] rwl[8]
+ rwl[7] rwl[6] rwl[5] rwl[4] rwl[3] rwl[2] rwl[1] rwl[0] rwlb[31] rwlb[30]
+ rwlb[29] rwlb[28] rwlb[27] rwlb[26] rwlb[25] rwlb[24] rwlb[23] rwlb[22]
+ rwlb[21] rwlb[20] rwlb[19] rwlb[18] rwlb[17] rwlb[16] rwlb[15] rwlb[14]
+ rwlb[13] rwlb[12] rwlb[11] rwlb[10] rwlb[9] rwlb[8] rwlb[7] rwlb[6] rwlb[5]
+ rwlb[4] rwlb[3] rwlb[2] rwlb[1] rwlb[0] wbl[15] wbl[14] wbl[13] wbl[12]
+ wbl[11] wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2]
+ wbl[1] wbl[0] wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9]
+ wblb[8] wblb[7] wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0]
+ rbl[15] rbl[14] rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6]
+ rbl[5] rbl[4] rbl[3] rbl[2] rbl[1] rbl[0]
Xword_0__w wwl[0] rwl[0] rwlb[0] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_0
Xword_1__w wwl[1] rwl[1] rwlb[1] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_63
Xword_2__w wwl[2] rwl[2] rwlb[2] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_62
Xword_3__w wwl[3] rwl[3] rwlb[3] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_61
Xword_4__w wwl[4] rwl[4] rwlb[4] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_60
Xword_5__w wwl[5] rwl[5] rwlb[5] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_59
Xword_6__w wwl[6] rwl[6] rwlb[6] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_58
Xword_7__w wwl[7] rwl[7] rwlb[7] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_57
Xword_8__w wwl[8] rwl[8] rwlb[8] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_56
Xword_9__w wwl[9] rwl[9] rwlb[9] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_55
Xword_10__w wwl[10] rwl[10] rwlb[10] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_54
Xword_11__w wwl[11] rwl[11] rwlb[11] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_53
Xword_12__w wwl[12] rwl[12] rwlb[12] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_52
Xword_13__w wwl[13] rwl[13] rwlb[13] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_51
Xword_14__w wwl[14] rwl[14] rwlb[14] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_50
Xword_15__w wwl[15] rwl[15] rwlb[15] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_49
Xword_16__w wwl[16] rwl[16] rwlb[16] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_48
Xword_17__w wwl[17] rwl[17] rwlb[17] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_47
Xword_18__w wwl[18] rwl[18] rwlb[18] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_46
Xword_19__w wwl[19] rwl[19] rwlb[19] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_45
Xword_20__w wwl[20] rwl[20] rwlb[20] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_44
Xword_21__w wwl[21] rwl[21] rwlb[21] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_43
Xword_22__w wwl[22] rwl[22] rwlb[22] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_42
Xword_23__w wwl[23] rwl[23] rwlb[23] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_41
Xword_24__w wwl[24] rwl[24] rwlb[24] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_40
Xword_25__w wwl[25] rwl[25] rwlb[25] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_39
Xword_26__w wwl[26] rwl[26] rwlb[26] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_38
Xword_27__w wwl[27] rwl[27] rwlb[27] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_37
Xword_28__w wwl[28] rwl[28] rwlb[28] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_36
Xword_29__w wwl[29] rwl[29] rwlb[29] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_35
Xword_30__w wwl[30] rwl[30] rwlb[30] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_34
Xword_31__w wwl[31] rwl[31] rwlb[31] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_33
.ENDS

.SUBCKT word_1 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_2 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_3 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_4 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_5 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_6 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_7 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_8 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_9 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_10 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_11 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_12 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_13 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_14 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_15 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_16 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_17 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_18 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_19 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_20 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_21 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_22 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_23 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_24 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_25 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_26 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_27 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_28 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_29 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_30 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_31 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT word_32 write read read_b write_data[15] write_data[14] write_data[13]
+ write_data[12] write_data[11] write_data[10] write_data[9] write_data[8]
+ write_data[7] write_data[6] write_data[5] write_data[4] write_data[3]
+ write_data[2] write_data[1] write_data[0] write_data_b[15] write_data_b[14]
+ write_data_b[13] write_data_b[12] write_data_b[11] write_data_b[10]
+ write_data_b[9] write_data_b[8] write_data_b[7] write_data_b[6]
+ write_data_b[5] write_data_b[4] write_data_b[3] write_data_b[2]
+ write_data_b[1] write_data_b[0] read_data[15] read_data[14] read_data[13]
+ read_data[12] read_data[11] read_data[10] read_data[9] read_data[8]
+ read_data[7] read_data[6] read_data[5] read_data[4] read_data[3] read_data[2]
+ read_data[1] read_data[0]
XU write_data[0] write_data_b[0] write read read_b read_data[0] bitcell
XU0 write_data[1] write_data_b[1] write read read_b read_data[1] bitcell
XU1 write_data[2] write_data_b[2] write read read_b read_data[2] bitcell
XU2 write_data[3] write_data_b[3] write read read_b read_data[3] bitcell
XU3 write_data[4] write_data_b[4] write read read_b read_data[4] bitcell
XU4 write_data[5] write_data_b[5] write read read_b read_data[5] bitcell
XU5 write_data[6] write_data_b[6] write read read_b read_data[6] bitcell
XU6 write_data[7] write_data_b[7] write read read_b read_data[7] bitcell
XU7 write_data[8] write_data_b[8] write read read_b read_data[8] bitcell
XU8 write_data[9] write_data_b[9] write read read_b read_data[9] bitcell
XU9 write_data[10] write_data_b[10] write read read_b read_data[10] bitcell
XU10 write_data[11] write_data_b[11] write read read_b read_data[11] bitcell
XU11 write_data[12] write_data_b[12] write read read_b read_data[12] bitcell
XU12 write_data[13] write_data_b[13] write read read_b read_data[13] bitcell
XU13 write_data[14] write_data_b[14] write read read_b read_data[14] bitcell
XU14 write_data[15] write_data_b[15] write read read_b read_data[15] bitcell
.ENDS

.SUBCKT array_1 wwl[31] wwl[30] wwl[29] wwl[28] wwl[27] wwl[26] wwl[25] wwl[24]
+ wwl[23] wwl[22] wwl[21] wwl[20] wwl[19] wwl[18] wwl[17] wwl[16] wwl[15]
+ wwl[14] wwl[13] wwl[12] wwl[11] wwl[10] wwl[9] wwl[8] wwl[7] wwl[6] wwl[5]
+ wwl[4] wwl[3] wwl[2] wwl[1] wwl[0] rwl[31] rwl[30] rwl[29] rwl[28] rwl[27]
+ rwl[26] rwl[25] rwl[24] rwl[23] rwl[22] rwl[21] rwl[20] rwl[19] rwl[18]
+ rwl[17] rwl[16] rwl[15] rwl[14] rwl[13] rwl[12] rwl[11] rwl[10] rwl[9] rwl[8]
+ rwl[7] rwl[6] rwl[5] rwl[4] rwl[3] rwl[2] rwl[1] rwl[0] rwlb[31] rwlb[30]
+ rwlb[29] rwlb[28] rwlb[27] rwlb[26] rwlb[25] rwlb[24] rwlb[23] rwlb[22]
+ rwlb[21] rwlb[20] rwlb[19] rwlb[18] rwlb[17] rwlb[16] rwlb[15] rwlb[14]
+ rwlb[13] rwlb[12] rwlb[11] rwlb[10] rwlb[9] rwlb[8] rwlb[7] rwlb[6] rwlb[5]
+ rwlb[4] rwlb[3] rwlb[2] rwlb[1] rwlb[0] wbl[15] wbl[14] wbl[13] wbl[12]
+ wbl[11] wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2]
+ wbl[1] wbl[0] wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9]
+ wblb[8] wblb[7] wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0]
+ rbl[15] rbl[14] rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6]
+ rbl[5] rbl[4] rbl[3] rbl[2] rbl[1] rbl[0]
Xword_0__w wwl[0] rwl[0] rwlb[0] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_32
Xword_1__w wwl[1] rwl[1] rwlb[1] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_31
Xword_2__w wwl[2] rwl[2] rwlb[2] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_30
Xword_3__w wwl[3] rwl[3] rwlb[3] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_29
Xword_4__w wwl[4] rwl[4] rwlb[4] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_28
Xword_5__w wwl[5] rwl[5] rwlb[5] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_27
Xword_6__w wwl[6] rwl[6] rwlb[6] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_26
Xword_7__w wwl[7] rwl[7] rwlb[7] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_25
Xword_8__w wwl[8] rwl[8] rwlb[8] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_24
Xword_9__w wwl[9] rwl[9] rwlb[9] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_23
Xword_10__w wwl[10] rwl[10] rwlb[10] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_22
Xword_11__w wwl[11] rwl[11] rwlb[11] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_21
Xword_12__w wwl[12] rwl[12] rwlb[12] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_20
Xword_13__w wwl[13] rwl[13] rwlb[13] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_19
Xword_14__w wwl[14] rwl[14] rwlb[14] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_18
Xword_15__w wwl[15] rwl[15] rwlb[15] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_17
Xword_16__w wwl[16] rwl[16] rwlb[16] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_16
Xword_17__w wwl[17] rwl[17] rwlb[17] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_15
Xword_18__w wwl[18] rwl[18] rwlb[18] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_14
Xword_19__w wwl[19] rwl[19] rwlb[19] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_13
Xword_20__w wwl[20] rwl[20] rwlb[20] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_12
Xword_21__w wwl[21] rwl[21] rwlb[21] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_11
Xword_22__w wwl[22] rwl[22] rwlb[22] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_10
Xword_23__w wwl[23] rwl[23] rwlb[23] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_9
Xword_24__w wwl[24] rwl[24] rwlb[24] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_8
Xword_25__w wwl[25] rwl[25] rwlb[25] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_7
Xword_26__w wwl[26] rwl[26] rwlb[26] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_6
Xword_27__w wwl[27] rwl[27] rwlb[27] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_5
Xword_28__w wwl[28] rwl[28] rwlb[28] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_4
Xword_29__w wwl[29] rwl[29] rwlb[29] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_3
Xword_30__w wwl[30] rwl[30] rwlb[30] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_2
Xword_31__w wwl[31] rwl[31] rwlb[31] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11]
+ wbl[10] wbl[9] wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0]
+ wblb[15] wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7]
+ wblb[6] wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] rbl[15] rbl[14]
+ rbl[13] rbl[12] rbl[11] rbl[10] rbl[9] rbl[8] rbl[7] rbl[6] rbl[5] rbl[4]
+ rbl[3] rbl[2] rbl[1] rbl[0] word_1
.ENDS

.SUBCKT mem_top CLK WEN A[5] A[4] A[3] A[2] A[1] A[0] D[15] D[14] D[13] D[12]
+ D[11] D[10] D[9] D[8] D[7] D[6] D[5] D[4] D[3] D[2] D[1] D[0] Q[15] Q[14]
+ Q[13] Q[12] Q[11] Q[10] Q[9] Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0]
Xdecoder WEN A[5] A[4] A[3] A[2] A[1] A[0] wwl[63] wwl[62] wwl[61] wwl[60]
+ wwl[59] wwl[58] wwl[57] wwl[56] wwl[55] wwl[54] wwl[53] wwl[52] wwl[51]
+ wwl[50] wwl[49] wwl[48] wwl[47] wwl[46] wwl[45] wwl[44] wwl[43] wwl[42]
+ wwl[41] wwl[40] wwl[39] wwl[38] wwl[37] wwl[36] wwl[35] wwl[34] wwl[33]
+ wwl[32] wwl[31] wwl[30] wwl[29] wwl[28] wwl[27] wwl[26] wwl[25] wwl[24]
+ wwl[23] wwl[22] wwl[21] wwl[20] wwl[19] wwl[18] wwl[17] wwl[16] wwl[15]
+ wwl[14] wwl[13] wwl[12] wwl[11] wwl[10] wwl[9] wwl[8] wwl[7] wwl[6] wwl[5]
+ wwl[4] wwl[3] wwl[2] wwl[1] wwl[0] rwl[31] rwl[30] rwl[29] rwl[28] rwl[27]
+ rwl[26] rwl[25] rwl[24] rwl[23] rwl[22] rwl[21] rwl[20] rwl[19] rwl[18]
+ rwl[17] rwl[16] rwl[15] rwl[14] rwl[13] rwl[12] rwl[11] rwl[10] rwl[9] rwl[8]
+ rwl[7] rwl[6] rwl[5] rwl[4] rwl[3] rwl[2] rwl[1] rwl[0] rwlb[31] rwlb[30]
+ rwlb[29] rwlb[28] rwlb[27] rwlb[26] rwlb[25] rwlb[24] rwlb[23] rwlb[22]
+ rwlb[21] rwlb[20] rwlb[19] rwlb[18] rwlb[17] rwlb[16] rwlb[15] rwlb[14]
+ rwlb[13] rwlb[12] rwlb[11] rwlb[10] rwlb[9] rwlb[8] rwlb[7] rwlb[6] rwlb[5]
+ rwlb[4] rwlb[3] rwlb[2] rwlb[1] rwlb[0] decoder
Xbitlines D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5] D[4]
+ D[3] D[2] D[1] D[0] wbl[15] wbl[14] wbl[13] wbl[12] wbl[11] wbl[10] wbl[9]
+ wbl[8] wbl[7] wbl[6] wbl[5] wbl[4] wbl[3] wbl[2] wbl[1] wbl[0] wblb[15]
+ wblb[14] wblb[13] wblb[12] wblb[11] wblb[10] wblb[9] wblb[8] wblb[7] wblb[6]
+ wblb[5] wblb[4] wblb[3] wblb[2] wblb[1] wblb[0] bitlines
Xwbl_latch_0 D[0] CLK wbl_latch[0] VDD VSS DFQD1
Xwbl_latch_1 D[1] CLK wbl_latch[1] VDD VSS DFQD1
Xwbl_latch_2 D[2] CLK wbl_latch[2] VDD VSS DFQD1
Xwbl_latch_3 D[3] CLK wbl_latch[3] VDD VSS DFQD1
Xwbl_latch_4 D[4] CLK wbl_latch[4] VDD VSS DFQD1
Xwbl_latch_5 D[5] CLK wbl_latch[5] VDD VSS DFQD1
Xwbl_latch_6 D[6] CLK wbl_latch[6] VDD VSS DFQD1
Xwbl_latch_7 D[7] CLK wbl_latch[7] VDD VSS DFQD1
Xwbl_latch_8 D[8] CLK wbl_latch[8] VDD VSS DFQD1
Xwbl_latch_9 D[9] CLK wbl_latch[9] VDD VSS DFQD1
Xwbl_latch_10 D[10] CLK wbl_latch[10] VDD VSS DFQD1
Xwbl_latch_11 D[11] CLK wbl_latch[11] VDD VSS DFQD1
Xwbl_latch_12 D[12] CLK wbl_latch[12] VDD VSS DFQD1
Xwbl_latch_13 D[13] CLK wbl_latch[13] VDD VSS DFQD1
Xwbl_latch_14 D[14] CLK wbl_latch[14] VDD VSS DFQD1
Xwbl_latch_15 D[15] CLK wbl_latch[15] VDD VSS DFQD1
Xwblb_latch_0 wblb[0] CLK wblb_latch[0] VDD VSS DFQD1
Xwblb_latch_1 wblb[1] CLK wblb_latch[1] VDD VSS DFQD1
Xwblb_latch_2 wblb[2] CLK wblb_latch[2] VDD VSS DFQD1
Xwblb_latch_3 wblb[3] CLK wblb_latch[3] VDD VSS DFQD1
Xwblb_latch_4 wblb[4] CLK wblb_latch[4] VDD VSS DFQD1
Xwblb_latch_5 wblb[5] CLK wblb_latch[5] VDD VSS DFQD1
Xwblb_latch_6 wblb[6] CLK wblb_latch[6] VDD VSS DFQD1
Xwblb_latch_7 wblb[7] CLK wblb_latch[7] VDD VSS DFQD1
Xwblb_latch_8 wblb[8] CLK wblb_latch[8] VDD VSS DFQD1
Xwblb_latch_9 wblb[9] CLK wblb_latch[9] VDD VSS DFQD1
Xwblb_latch_10 wblb[10] CLK wblb_latch[10] VDD VSS DFQD1
Xwblb_latch_11 wblb[11] CLK wblb_latch[11] VDD VSS DFQD1
Xwblb_latch_12 wblb[12] CLK wblb_latch[12] VDD VSS DFQD1
Xwblb_latch_13 wblb[13] CLK wblb_latch[13] VDD VSS DFQD1
Xwblb_latch_14 wblb[14] CLK wblb_latch[14] VDD VSS DFQD1
Xwblb_latch_15 wblb[15] CLK wblb_latch[15] VDD VSS DFQD1
Xarray_0 wwl_wire[31] wwl_wire[30] wwl_wire[29] wwl_wire[28] wwl_wire[27]
+ wwl_wire[26] wwl_wire[25] wwl_wire[24] wwl_wire[23] wwl_wire[22] wwl_wire[21]
+ wwl_wire[20] wwl_wire[19] wwl_wire[18] wwl_wire[17] wwl_wire[16] wwl_wire[15]
+ wwl_wire[14] wwl_wire[13] wwl_wire[12] wwl_wire[11] wwl_wire[10] wwl_wire[9]
+ wwl_wire[8] wwl_wire[7] wwl_wire[6] wwl_wire[5] wwl_wire[4] wwl_wire[3]
+ wwl_wire[2] wwl_wire[1] wwl_wire[0] rwl[31] rwl[30] rwl[29] rwl[28] rwl[27]
+ rwl[26] rwl[25] rwl[24] rwl[23] rwl[22] rwl[21] rwl[20] rwl[19] rwl[18]
+ rwl[17] rwl[16] rwl[15] rwl[14] rwl[13] rwl[12] rwl[11] rwl[10] rwl[9] rwl[8]
+ rwl[7] rwl[6] rwl[5] rwl[4] rwl[3] rwl[2] rwl[1] rwl[0] rwlb[31] rwlb[30]
+ rwlb[29] rwlb[28] rwlb[27] rwlb[26] rwlb[25] rwlb[24] rwlb[23] rwlb[22]
+ rwlb[21] rwlb[20] rwlb[19] rwlb[18] rwlb[17] rwlb[16] rwlb[15] rwlb[14]
+ rwlb[13] rwlb[12] rwlb[11] rwlb[10] rwlb[9] rwlb[8] rwlb[7] rwlb[6] rwlb[5]
+ rwlb[4] rwlb[3] rwlb[2] rwlb[1] rwlb[0] wbl_latch[15] wbl_latch[14]
+ wbl_latch[13] wbl_latch[12] wbl_latch[11] wbl_latch[10] wbl_latch[9]
+ wbl_latch[8] wbl_latch[7] wbl_latch[6] wbl_latch[5] wbl_latch[4] wbl_latch[3]
+ wbl_latch[2] wbl_latch[1] wbl_latch[0] wblb_latch[15] wblb_latch[14]
+ wblb_latch[13] wblb_latch[12] wblb_latch[11] wblb_latch[10] wblb_latch[9]
+ wblb_latch[8] wblb_latch[7] wblb_latch[6] wblb_latch[5] wblb_latch[4]
+ wblb_latch[3] wblb_latch[2] wblb_latch[1] wblb_latch[0] q_wire_0[15]
+ q_wire_0[14] q_wire_0[13] q_wire_0[12] q_wire_0[11] q_wire_0[10] q_wire_0[9]
+ q_wire_0[8] q_wire_0[7] q_wire_0[6] q_wire_0[5] q_wire_0[4] q_wire_0[3]
+ q_wire_0[2] q_wire_0[1] q_wire_0[0] array_0
Xarray_1 wwl_wire[63] wwl_wire[62] wwl_wire[61] wwl_wire[60] wwl_wire[59]
+ wwl_wire[58] wwl_wire[57] wwl_wire[56] wwl_wire[55] wwl_wire[54] wwl_wire[53]
+ wwl_wire[52] wwl_wire[51] wwl_wire[50] wwl_wire[49] wwl_wire[48] wwl_wire[47]
+ wwl_wire[46] wwl_wire[45] wwl_wire[44] wwl_wire[43] wwl_wire[42] wwl_wire[41]
+ wwl_wire[40] wwl_wire[39] wwl_wire[38] wwl_wire[37] wwl_wire[36] wwl_wire[35]
+ wwl_wire[34] wwl_wire[33] wwl_wire[32] rwl[31] rwl[30] rwl[29] rwl[28]
+ rwl[27] rwl[26] rwl[25] rwl[24] rwl[23] rwl[22] rwl[21] rwl[20] rwl[19]
+ rwl[18] rwl[17] rwl[16] rwl[15] rwl[14] rwl[13] rwl[12] rwl[11] rwl[10]
+ rwl[9] rwl[8] rwl[7] rwl[6] rwl[5] rwl[4] rwl[3] rwl[2] rwl[1] rwl[0]
+ rwlb[31] rwlb[30] rwlb[29] rwlb[28] rwlb[27] rwlb[26] rwlb[25] rwlb[24]
+ rwlb[23] rwlb[22] rwlb[21] rwlb[20] rwlb[19] rwlb[18] rwlb[17] rwlb[16]
+ rwlb[15] rwlb[14] rwlb[13] rwlb[12] rwlb[11] rwlb[10] rwlb[9] rwlb[8] rwlb[7]
+ rwlb[6] rwlb[5] rwlb[4] rwlb[3] rwlb[2] rwlb[1] rwlb[0] wbl_latch[15]
+ wbl_latch[14] wbl_latch[13] wbl_latch[12] wbl_latch[11] wbl_latch[10]
+ wbl_latch[9] wbl_latch[8] wbl_latch[7] wbl_latch[6] wbl_latch[5] wbl_latch[4]
+ wbl_latch[3] wbl_latch[2] wbl_latch[1] wbl_latch[0] wblb_latch[15]
+ wblb_latch[14] wblb_latch[13] wblb_latch[12] wblb_latch[11] wblb_latch[10]
+ wblb_latch[9] wblb_latch[8] wblb_latch[7] wblb_latch[6] wblb_latch[5]
+ wblb_latch[4] wblb_latch[3] wblb_latch[2] wblb_latch[1] wblb_latch[0]
+ q_wire_1[15] q_wire_1[14] q_wire_1[13] q_wire_1[12] q_wire_1[11] q_wire_1[10]
+ q_wire_1[9] q_wire_1[8] q_wire_1[7] q_wire_1[6] q_wire_1[5] q_wire_1[4]
+ q_wire_1[3] q_wire_1[2] q_wire_1[1] q_wire_1[0] array_1
XC291 wwl_latch[63] CLK wwl_wire[63] VDD VSS AN2XD1LVT
XC290 wwl_latch[62] CLK wwl_wire[62] VDD VSS AN2XD1LVT
XC289 wwl_latch[61] CLK wwl_wire[61] VDD VSS AN2XD1LVT
XC288 wwl_latch[60] CLK wwl_wire[60] VDD VSS AN2XD1LVT
XC287 wwl_latch[59] CLK wwl_wire[59] VDD VSS AN2XD1LVT
XC286 wwl_latch[58] CLK wwl_wire[58] VDD VSS AN2XD1LVT
XC285 wwl_latch[57] CLK wwl_wire[57] VDD VSS AN2XD1LVT
XC284 wwl_latch[56] CLK wwl_wire[56] VDD VSS AN2XD1LVT
XC283 wwl_latch[55] CLK wwl_wire[55] VDD VSS AN2XD1LVT
XC282 wwl_latch[54] CLK wwl_wire[54] VDD VSS AN2XD1LVT
XC281 wwl_latch[53] CLK wwl_wire[53] VDD VSS AN2XD1LVT
XC280 wwl_latch[52] CLK wwl_wire[52] VDD VSS AN2XD1LVT
XC279 wwl_latch[51] CLK wwl_wire[51] VDD VSS AN2XD1LVT
XC278 wwl_latch[50] CLK wwl_wire[50] VDD VSS AN2XD1LVT
XC277 wwl_latch[49] CLK wwl_wire[49] VDD VSS AN2XD1LVT
XC276 wwl_latch[48] CLK wwl_wire[48] VDD VSS AN2XD1LVT
XC275 wwl_latch[47] CLK wwl_wire[47] VDD VSS AN2XD1LVT
XC274 wwl_latch[46] CLK wwl_wire[46] VDD VSS AN2XD1LVT
XC273 wwl_latch[45] CLK wwl_wire[45] VDD VSS AN2XD1LVT
XC272 wwl_latch[44] CLK wwl_wire[44] VDD VSS AN2XD1LVT
XC271 wwl_latch[43] CLK wwl_wire[43] VDD VSS AN2XD1LVT
XC270 wwl_latch[42] CLK wwl_wire[42] VDD VSS AN2XD1LVT
XC269 wwl_latch[41] CLK wwl_wire[41] VDD VSS AN2XD1LVT
XC268 wwl_latch[40] CLK wwl_wire[40] VDD VSS AN2XD1LVT
XC267 wwl_latch[39] CLK wwl_wire[39] VDD VSS AN2XD1LVT
XC266 wwl_latch[38] CLK wwl_wire[38] VDD VSS AN2XD1LVT
XC265 wwl_latch[37] CLK wwl_wire[37] VDD VSS AN2XD1LVT
XC264 wwl_latch[36] CLK wwl_wire[36] VDD VSS AN2XD1LVT
XC263 wwl_latch[35] CLK wwl_wire[35] VDD VSS AN2XD1LVT
XC262 wwl_latch[34] CLK wwl_wire[34] VDD VSS AN2XD1LVT
XC261 wwl_latch[33] CLK wwl_wire[33] VDD VSS AN2XD1LVT
XC260 wwl_latch[32] CLK wwl_wire[32] VDD VSS AN2XD1LVT
XC259 wwl_latch[31] CLK wwl_wire[31] VDD VSS AN2XD1LVT
XC258 wwl_latch[30] CLK wwl_wire[30] VDD VSS AN2XD1LVT
XC257 wwl_latch[29] CLK wwl_wire[29] VDD VSS AN2XD1LVT
XC256 wwl_latch[28] CLK wwl_wire[28] VDD VSS AN2XD1LVT
XC255 wwl_latch[27] CLK wwl_wire[27] VDD VSS AN2XD1LVT
XC254 wwl_latch[26] CLK wwl_wire[26] VDD VSS AN2XD1LVT
XC253 wwl_latch[25] CLK wwl_wire[25] VDD VSS AN2XD1LVT
XC252 wwl_latch[24] CLK wwl_wire[24] VDD VSS AN2XD1LVT
XC251 wwl_latch[23] CLK wwl_wire[23] VDD VSS AN2XD1LVT
XC250 wwl_latch[22] CLK wwl_wire[22] VDD VSS AN2XD1LVT
XC249 wwl_latch[21] CLK wwl_wire[21] VDD VSS AN2XD1LVT
XC248 wwl_latch[20] CLK wwl_wire[20] VDD VSS AN2XD1LVT
XC247 wwl_latch[19] CLK wwl_wire[19] VDD VSS AN2XD1LVT
XC246 wwl_latch[18] CLK wwl_wire[18] VDD VSS AN2XD1LVT
XC245 wwl_latch[17] CLK wwl_wire[17] VDD VSS AN2XD1LVT
XC244 wwl_latch[16] CLK wwl_wire[16] VDD VSS AN2XD1LVT
XC243 wwl_latch[15] CLK wwl_wire[15] VDD VSS AN2XD1LVT
XC242 wwl_latch[14] CLK wwl_wire[14] VDD VSS AN2XD1LVT
XC241 wwl_latch[13] CLK wwl_wire[13] VDD VSS AN2XD1LVT
XC240 wwl_latch[12] CLK wwl_wire[12] VDD VSS AN2XD1LVT
XC239 wwl_latch[11] CLK wwl_wire[11] VDD VSS AN2XD1LVT
XC238 wwl_latch[10] CLK wwl_wire[10] VDD VSS AN2XD1LVT
XC237 wwl_latch[9] CLK wwl_wire[9] VDD VSS AN2XD1LVT
XC236 wwl_latch[8] CLK wwl_wire[8] VDD VSS AN2XD1LVT
XC235 wwl_latch[7] CLK wwl_wire[7] VDD VSS AN2XD1LVT
XC234 wwl_latch[6] CLK wwl_wire[6] VDD VSS AN2XD1LVT
XC233 wwl_latch[5] CLK wwl_wire[5] VDD VSS AN2XD1LVT
XC232 wwl_latch[4] CLK wwl_wire[4] VDD VSS AN2XD1LVT
XC231 wwl_latch[3] CLK wwl_wire[3] VDD VSS AN2XD1LVT
XC230 wwl_latch[2] CLK wwl_wire[2] VDD VSS AN2XD1LVT
XC229 wwl_latch[1] CLK wwl_wire[1] VDD VSS AN2XD1LVT
XC228 wwl_latch[0] CLK wwl_wire[0] VDD VSS AN2XD1LVT
Xwwl_latch_reg_63_ wwl[63] CLK wwl_latch[63] VDD VSS LNQD1LVT
Xwwl_latch_reg_62_ wwl[62] CLK wwl_latch[62] VDD VSS LNQD1LVT
Xwwl_latch_reg_61_ wwl[61] CLK wwl_latch[61] VDD VSS LNQD1LVT
Xwwl_latch_reg_60_ wwl[60] CLK wwl_latch[60] VDD VSS LNQD1LVT
Xwwl_latch_reg_59_ wwl[59] CLK wwl_latch[59] VDD VSS LNQD1LVT
Xwwl_latch_reg_58_ wwl[58] CLK wwl_latch[58] VDD VSS LNQD1LVT
Xwwl_latch_reg_57_ wwl[57] CLK wwl_latch[57] VDD VSS LNQD1LVT
Xwwl_latch_reg_56_ wwl[56] CLK wwl_latch[56] VDD VSS LNQD1LVT
Xwwl_latch_reg_55_ wwl[55] CLK wwl_latch[55] VDD VSS LNQD1LVT
Xwwl_latch_reg_54_ wwl[54] CLK wwl_latch[54] VDD VSS LNQD1LVT
Xwwl_latch_reg_53_ wwl[53] CLK wwl_latch[53] VDD VSS LNQD1LVT
Xwwl_latch_reg_52_ wwl[52] CLK wwl_latch[52] VDD VSS LNQD1LVT
Xwwl_latch_reg_51_ wwl[51] CLK wwl_latch[51] VDD VSS LNQD1LVT
Xwwl_latch_reg_50_ wwl[50] CLK wwl_latch[50] VDD VSS LNQD1LVT
Xwwl_latch_reg_49_ wwl[49] CLK wwl_latch[49] VDD VSS LNQD1LVT
Xwwl_latch_reg_48_ wwl[48] CLK wwl_latch[48] VDD VSS LNQD1LVT
Xwwl_latch_reg_47_ wwl[47] CLK wwl_latch[47] VDD VSS LNQD1LVT
Xwwl_latch_reg_46_ wwl[46] CLK wwl_latch[46] VDD VSS LNQD1LVT
Xwwl_latch_reg_45_ wwl[45] CLK wwl_latch[45] VDD VSS LNQD1LVT
Xwwl_latch_reg_44_ wwl[44] CLK wwl_latch[44] VDD VSS LNQD1LVT
Xwwl_latch_reg_43_ wwl[43] CLK wwl_latch[43] VDD VSS LNQD1LVT
Xwwl_latch_reg_42_ wwl[42] CLK wwl_latch[42] VDD VSS LNQD1LVT
Xwwl_latch_reg_41_ wwl[41] CLK wwl_latch[41] VDD VSS LNQD1LVT
Xwwl_latch_reg_40_ wwl[40] CLK wwl_latch[40] VDD VSS LNQD1LVT
Xwwl_latch_reg_39_ wwl[39] CLK wwl_latch[39] VDD VSS LNQD1LVT
Xwwl_latch_reg_38_ wwl[38] CLK wwl_latch[38] VDD VSS LNQD1LVT
Xwwl_latch_reg_37_ wwl[37] CLK wwl_latch[37] VDD VSS LNQD1LVT
Xwwl_latch_reg_36_ wwl[36] CLK wwl_latch[36] VDD VSS LNQD1LVT
Xwwl_latch_reg_35_ wwl[35] CLK wwl_latch[35] VDD VSS LNQD1LVT
Xwwl_latch_reg_34_ wwl[34] CLK wwl_latch[34] VDD VSS LNQD1LVT
Xwwl_latch_reg_33_ wwl[33] CLK wwl_latch[33] VDD VSS LNQD1LVT
Xwwl_latch_reg_32_ wwl[32] CLK wwl_latch[32] VDD VSS LNQD1LVT
Xwwl_latch_reg_31_ wwl[31] CLK wwl_latch[31] VDD VSS LNQD1LVT
Xwwl_latch_reg_30_ wwl[30] CLK wwl_latch[30] VDD VSS LNQD1LVT
Xwwl_latch_reg_29_ wwl[29] CLK wwl_latch[29] VDD VSS LNQD1LVT
Xwwl_latch_reg_28_ wwl[28] CLK wwl_latch[28] VDD VSS LNQD1LVT
Xwwl_latch_reg_27_ wwl[27] CLK wwl_latch[27] VDD VSS LNQD1LVT
Xwwl_latch_reg_26_ wwl[26] CLK wwl_latch[26] VDD VSS LNQD1LVT
Xwwl_latch_reg_25_ wwl[25] CLK wwl_latch[25] VDD VSS LNQD1LVT
Xwwl_latch_reg_24_ wwl[24] CLK wwl_latch[24] VDD VSS LNQD1LVT
Xwwl_latch_reg_23_ wwl[23] CLK wwl_latch[23] VDD VSS LNQD1LVT
Xwwl_latch_reg_22_ wwl[22] CLK wwl_latch[22] VDD VSS LNQD1LVT
Xwwl_latch_reg_21_ wwl[21] CLK wwl_latch[21] VDD VSS LNQD1LVT
Xwwl_latch_reg_20_ wwl[20] CLK wwl_latch[20] VDD VSS LNQD1LVT
Xwwl_latch_reg_19_ wwl[19] CLK wwl_latch[19] VDD VSS LNQD1LVT
Xwwl_latch_reg_18_ wwl[18] CLK wwl_latch[18] VDD VSS LNQD1LVT
Xwwl_latch_reg_17_ wwl[17] CLK wwl_latch[17] VDD VSS LNQD1LVT
Xwwl_latch_reg_16_ wwl[16] CLK wwl_latch[16] VDD VSS LNQD1LVT
Xwwl_latch_reg_15_ wwl[15] CLK wwl_latch[15] VDD VSS LNQD1LVT
Xwwl_latch_reg_14_ wwl[14] CLK wwl_latch[14] VDD VSS LNQD1LVT
Xwwl_latch_reg_13_ wwl[13] CLK wwl_latch[13] VDD VSS LNQD1LVT
Xwwl_latch_reg_12_ wwl[12] CLK wwl_latch[12] VDD VSS LNQD1LVT
Xwwl_latch_reg_11_ wwl[11] CLK wwl_latch[11] VDD VSS LNQD1LVT
Xwwl_latch_reg_10_ wwl[10] CLK wwl_latch[10] VDD VSS LNQD1LVT
Xwwl_latch_reg_9_ wwl[9] CLK wwl_latch[9] VDD VSS LNQD1LVT
Xwwl_latch_reg_8_ wwl[8] CLK wwl_latch[8] VDD VSS LNQD1LVT
Xwwl_latch_reg_7_ wwl[7] CLK wwl_latch[7] VDD VSS LNQD1LVT
Xwwl_latch_reg_6_ wwl[6] CLK wwl_latch[6] VDD VSS LNQD1LVT
Xwwl_latch_reg_5_ wwl[5] CLK wwl_latch[5] VDD VSS LNQD1LVT
Xwwl_latch_reg_4_ wwl[4] CLK wwl_latch[4] VDD VSS LNQD1LVT
Xwwl_latch_reg_3_ wwl[3] CLK wwl_latch[3] VDD VSS LNQD1LVT
Xwwl_latch_reg_2_ wwl[2] CLK wwl_latch[2] VDD VSS LNQD1LVT
Xwwl_latch_reg_1_ wwl[1] CLK wwl_latch[1] VDD VSS LNQD1LVT
Xwwl_latch_reg_0_ wwl[0] CLK wwl_latch[0] VDD VSS LNQD1LVT
XU2 A[5] n1 VDD VSS INVD1LVT
XU3 q_wire_1[0] A[5] q_wire_0[0] n1 Q[0] VDD VSS AO22D0LVT
XU4 q_wire_1[1] A[5] q_wire_0[1] n1 Q[1] VDD VSS AO22D0LVT
XU5 q_wire_1[2] A[5] q_wire_0[2] n1 Q[2] VDD VSS AO22D0LVT
XU6 q_wire_1[3] A[5] q_wire_0[3] n1 Q[3] VDD VSS AO22D0LVT
XU7 q_wire_1[4] A[5] q_wire_0[4] n1 Q[4] VDD VSS AO22D0LVT
XU8 q_wire_1[5] A[5] q_wire_0[5] n1 Q[5] VDD VSS AO22D0LVT
XU9 q_wire_1[6] A[5] q_wire_0[6] n1 Q[6] VDD VSS AO22D0LVT
XU10 q_wire_1[7] A[5] q_wire_0[7] n1 Q[7] VDD VSS AO22D0LVT
XU11 q_wire_1[8] A[5] q_wire_0[8] n1 Q[8] VDD VSS AO22D0LVT
XU12 q_wire_1[9] A[5] q_wire_0[9] n1 Q[9] VDD VSS AO22D0LVT
XU13 q_wire_1[10] A[5] q_wire_0[10] n1 Q[10] VDD VSS AO22D0LVT
XU14 q_wire_1[11] A[5] q_wire_0[11] n1 Q[11] VDD VSS AO22D0LVT
XU15 q_wire_1[12] A[5] q_wire_0[12] n1 Q[12] VDD VSS AO22D0LVT
XU16 q_wire_1[13] A[5] q_wire_0[13] n1 Q[13] VDD VSS AO22D0LVT
XU17 q_wire_1[14] A[5] q_wire_0[14] n1 Q[14] VDD VSS AO22D0LVT
XU18 q_wire_1[15] A[5] q_wire_0[15] n1 Q[15] VDD VSS AO22D0LVT
.ENDS

.SUBCKT mem_pipeline CLK WEN A[5] A[4] A[3] A[2] A[1] A[0] D[15] D[14] D[13]
+ D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5] D[4] D[3] D[2] D[1] D[0] Q[15]
+ Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1]
+ Q[0]
Xmem_top CLK wen_reg a_reg[5] a_reg[4] a_reg[3] a_reg[2] a_reg[1] a_reg[0]
+ d_reg[15] d_reg[14] d_reg[13] d_reg[12] d_reg[11] d_reg[10] d_reg[9] d_reg[8]
+ d_reg[7] d_reg[6] d_reg[5] d_reg[4] d_reg[3] d_reg[2] d_reg[1] d_reg[0]
+ q_wire[15] q_wire[14] q_wire[13] q_wire[12] q_wire[11] q_wire[10] q_wire[9]
+ q_wire[8] q_wire[7] q_wire[6] q_wire[5] q_wire[4] q_wire[3] q_wire[2]
+ q_wire[1] q_wire[0] mem_top
Xwen_reg_reg WEN CLK wen_reg VDD VSS DFQD1
Xa_reg_reg_5_ A[5] CLK a_reg[5] VDD VSS DFQD1
Xa_reg_reg_4_ A[4] CLK a_reg[4] VDD VSS DFQD1
Xa_reg_reg_3_ A[3] CLK a_reg[3] VDD VSS DFQD1
Xa_reg_reg_2_ A[2] CLK a_reg[2] VDD VSS DFQD1
Xa_reg_reg_1_ A[1] CLK a_reg[1] VDD VSS DFQD1
Xa_reg_reg_0_ A[0] CLK a_reg[0] VDD VSS DFQD1
Xd_reg_reg_15_ D[15] CLK d_reg[15] VDD VSS DFQD1
Xd_reg_reg_14_ D[14] CLK d_reg[14] VDD VSS DFQD1
Xd_reg_reg_13_ D[13] CLK d_reg[13] VDD VSS DFQD1
Xd_reg_reg_12_ D[12] CLK d_reg[12] VDD VSS DFQD1
Xd_reg_reg_11_ D[11] CLK d_reg[11] VDD VSS DFQD1
Xd_reg_reg_10_ D[10] CLK d_reg[10] VDD VSS DFQD1
Xd_reg_reg_9_ D[9] CLK d_reg[9] VDD VSS DFQD1
Xd_reg_reg_8_ D[8] CLK d_reg[8] VDD VSS DFQD1
Xd_reg_reg_7_ D[7] CLK d_reg[7] VDD VSS DFQD1
Xd_reg_reg_6_ D[6] CLK d_reg[6] VDD VSS DFQD1
Xd_reg_reg_5_ D[5] CLK d_reg[5] VDD VSS DFQD1
Xd_reg_reg_4_ D[4] CLK d_reg[4] VDD VSS DFQD1
Xd_reg_reg_3_ D[3] CLK d_reg[3] VDD VSS DFQD1
Xd_reg_reg_2_ D[2] CLK d_reg[2] VDD VSS DFQD1
Xd_reg_reg_1_ D[1] CLK d_reg[1] VDD VSS DFQD1
Xd_reg_reg_0_ D[0] CLK d_reg[0] VDD VSS DFQD1
XQ_reg_15_ q_wire[15] CLK Q[15] VDD VSS DFQD1
XQ_reg_14_ q_wire[14] CLK Q[14] VDD VSS DFQD1
XQ_reg_13_ q_wire[13] CLK Q[13] VDD VSS DFQD1
XQ_reg_12_ q_wire[12] CLK Q[12] VDD VSS DFQD1
XQ_reg_11_ q_wire[11] CLK Q[11] VDD VSS DFQD1
XQ_reg_10_ q_wire[10] CLK Q[10] VDD VSS DFQD1
XQ_reg_9_ q_wire[9] CLK Q[9] VDD VSS DFQD1
XQ_reg_8_ q_wire[8] CLK Q[8] VDD VSS DFQD1
XQ_reg_7_ q_wire[7] CLK Q[7] VDD VSS DFQD1
XQ_reg_6_ q_wire[6] CLK Q[6] VDD VSS DFQD1
XQ_reg_5_ q_wire[5] CLK Q[5] VDD VSS DFQD1
XQ_reg_4_ q_wire[4] CLK Q[4] VDD VSS DFQD1
XQ_reg_3_ q_wire[3] CLK Q[3] VDD VSS DFQD1
XQ_reg_2_ q_wire[2] CLK Q[2] VDD VSS DFQD1
XQ_reg_1_ q_wire[1] CLK Q[1] VDD VSS DFQD1
XQ_reg_0_ q_wire[0] CLK Q[0] VDD VSS DFQD1
.ENDS

.SUBCKT bitcell WBL WBLB WWL RWL RWLB RBL
 XM6 net1 QB VDD VDD pch_mac w=360.0n l=60n
 XM5 net1 RWLB RBL VDD pch_mac w=120.0n l=60n
 XM4 Q QB VDD VDD pch_mac w=360.0n  l=60n
 XM3 QB Q VDD VDD pch_mac w=360.0n l=60n
 XM9 WBL WWL Q VSS nch_mac w=240.0n  l=60n
 XM8 WBLB WWL QB VSS nch_mac w=240.0n  l=60n
 XM7 net1 QB VSS VSS nch_mac w=120.0n l=60n
 XM2 net1 RWL RBL VSS nch_mac w=120.0n  l=60n
 XM1 Q QB VSS VSS nch_mac w=120.0n l=60n
 XM0 QB Q VSS VSS nch_mac w=120.0n l=60n
.ENDS
.GLOBAL VDD
.GLOBAL VSS

.ic
+ xmem_top.Xarray_0.N_XI797/Q_XI797/MM10_s = 0

.ic
+xsram.q0 = 'supply0'
+xsram.q1 = 'supply0'
+xsram.q2 = 'supply0'
+xsram.q3 = 'supply0'
+xsram.q4 = 'supply0'
+xsram.q5 = 'supply0'
+xsram.q6 = 'supply0'
+xsram.q7 = 'supply0'
+xsram.q8 = 'supply0'
+xsram.q9 = 'supply0'
+xsram.q10 = 'supply0'
+xsram.q11 = 'supply0'
+xsram.q12 = 'supply0'
+xsram.q13 = 'supply0'
+xsram.q14 = 'supply0'
+xsram.q15 = 'supply0'
+xsram.wen_reg ='supply0'
+xsram.Xmem_top.wwl_latch3 = 0
+xsram.Xmem_top.wwl_latch2 = 0
+xsram.Xmem_top.wwl_latch1 = 0
+xsram.Xmem_top.wwl_latch0 = 0
*+xsram.q_wire2 = 0
*+xsram.q_wire3 = 'supply0'
*bitline 0
+xsram.Xmem_top.Xarray0.XI4.Q = 0
+xsram.Xmem_top.Xarray0.XI6.Q = 0
+xsram.Xmem_top.Xarray0.XI7.Q = 0
+xsram.Xmem_top.Xarray0.XI8.Q = 0
*bitline 1
*+xsram.Xmem_top.Xarray0.XI12.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI10.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI11.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI9.Q = 'supply0'
*bitline 2
*don't set the XI19.Q=supply0
+xsram.Xmem_top.Xarray0.XI19.Q = 0
+xsram.Xmem_top.Xarray0.XI17.Q = 0
+xsram.Xmem_top.Xarray0.XI16.Q = 0
+xsram.Xmem_top.Xarray0.XI13.Q = 0
*bitline 3
*don't set the XI20.Q=0
+xsram.Xmem_top.Xarray0.XI20.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI18.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI15.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI14.Q = 'supply0'
*bitline 4
+xsram.Xmem_top.Xarray0.XI33.Q = 0
+xsram.Xmem_top.Xarray0.XI29.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI26.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI21.Q = 'supply0'
*bitline 5
+xsram.Xmem_top.Xarray0.XI34.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI30.Q = 0
+xsram.Xmem_top.Xarray0.XI27.Q = 0
+xsram.Xmem_top.Xarray0.XI22.Q = 0
*bitline 6
+xsram.Xmem_top.Xarray0.XI36.Q = 0
+xsram.Xmem_top.Xarray0.XI32.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI27.Q = 0
+xsram.Xmem_top.Xarray0.XI24.Q = 'supply0'
*bitline 7
+xsram.Xmem_top.Xarray0.XI36.Q = 0
+xsram.Xmem_top.Xarray0.XI32.Q = 'supply0'
+xsram.Xmem_top.Xarray0.XI27.Q = 0
+xsram.Xmem_top.Xarray0.XI24.Q = 'supply0'

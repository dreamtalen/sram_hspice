.ic
+ xmem_pipeline.xmem_top.Xarray_0.N_XI797/Q_XI797/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI794/Q_XI794/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI791/Q_XI791/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI790/Q_XI790/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI796/Q_XI796/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI795/Q_XI795/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI788/Q_XI788/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI787/Q_XI787/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI786/Q_XI786/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI793/Q_XI793/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI792/Q_XI792/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI784/Q_XI784/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI783/Q_XI783/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI782/Q_XI782/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI785/Q_XI785/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI789/Q_XI789/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI1020/Q_XI1020/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI1036/Q_XI1036/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI972/Q_XI972/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI988/Q_XI988/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI940/Q_XI940/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI956/Q_XI956/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI908/Q_XI908/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI924/Q_XI924/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI860/Q_XI860/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI892/Q_XI892/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI876/Q_XI876/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI828/Q_XI828/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI844/Q_XI844/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI812/Q_XI812/MM10_s = 350m
+ xmem_pipeline.xmem_top.Xarray_0.N_XI1004/Q_XI1004/MM10_s = 350m
+ xmem_pipeline.xmem_top.q_wire_1[0] = 0
+ xmem_pipeline.xmem_top.q_wire_1[1] = 0
+ xmem_pipeline.xmem_top.q_wire_1[2] = 0
+ xmem_pipeline.xmem_top.q_wire_1[3] = 0
+ xmem_pipeline.xmem_top.q_wire_1[4] = 0
+ xmem_pipeline.xmem_top.q_wire_1[5] = 0
+ xmem_pipeline.xmem_top.q_wire_1[6] = 0
+ xmem_pipeline.xmem_top.q_wire_1[7] = 0
+ xmem_pipeline.xmem_top.q_wire_1[8] = 0
+ xmem_pipeline.xmem_top.q_wire_1[9] = 0
+ xmem_pipeline.xmem_top.q_wire_1[10] = 0
+ xmem_pipeline.xmem_top.q_wire_1[11] = 0
+ xmem_pipeline.xmem_top.q_wire_1[12] = 0
+ xmem_pipeline.xmem_top.q_wire_1[13] = 0
+ xmem_pipeline.xmem_top.q_wire_1[14] = 0
+ xmem_pipeline.xmem_top.q_wire_1[15] = 0
+ xmem_pipeline.xmem_top.q_wire_2[0] = 0
+ xmem_pipeline.xmem_top.q_wire_2[1] = 0
+ xmem_pipeline.xmem_top.q_wire_2[2] = 0
+ xmem_pipeline.xmem_top.q_wire_2[3] = 0
+ xmem_pipeline.xmem_top.q_wire_2[4] = 0
+ xmem_pipeline.xmem_top.q_wire_2[5] = 0
+ xmem_pipeline.xmem_top.q_wire_2[6] = 0
+ xmem_pipeline.xmem_top.q_wire_2[7] = 0
+ xmem_pipeline.xmem_top.q_wire_2[8] = 0
+ xmem_pipeline.xmem_top.q_wire_2[9] = 0
+ xmem_pipeline.xmem_top.q_wire_2[10] = 0
+ xmem_pipeline.xmem_top.q_wire_2[11] = 0
+ xmem_pipeline.xmem_top.q_wire_2[12] = 0
+ xmem_pipeline.xmem_top.q_wire_2[13] = 0
+ xmem_pipeline.xmem_top.q_wire_2[14] = 0
+ xmem_pipeline.xmem_top.q_wire_2[15] = 0
+ xmem_pipeline.xmem_top.q_wire_3[0] = 0
+ xmem_pipeline.xmem_top.q_wire_3[1] = 0
+ xmem_pipeline.xmem_top.q_wire_3[2] = 0
+ xmem_pipeline.xmem_top.q_wire_3[3] = 0
+ xmem_pipeline.xmem_top.q_wire_3[4] = 0
+ xmem_pipeline.xmem_top.q_wire_3[5] = 0
+ xmem_pipeline.xmem_top.q_wire_3[6] = 0
+ xmem_pipeline.xmem_top.q_wire_3[7] = 0
+ xmem_pipeline.xmem_top.q_wire_3[8] = 0
+ xmem_pipeline.xmem_top.q_wire_3[9] = 0
+ xmem_pipeline.xmem_top.q_wire_3[10] = 0
+ xmem_pipeline.xmem_top.q_wire_3[11] = 0
+ xmem_pipeline.xmem_top.q_wire_3[12] = 0
+ xmem_pipeline.xmem_top.q_wire_3[13] = 0
+ xmem_pipeline.xmem_top.q_wire_3[14] = 0
+ xmem_pipeline.xmem_top.q_wire_3[15] = 0

.ic
+ xmem_pipeline.xmem_top.Xarray_0.N_XI797/Q_XI797/MM10_s = 0
+ xmem_pipeline.xmem_top.q_wire_1[0] = 0
+ xmem_pipeline.xmem_top.q_wire_1[1] = 0
+ xmem_pipeline.xmem_top.q_wire_1[2] = 0
+ xmem_pipeline.xmem_top.q_wire_1[3] = 0
+ xmem_pipeline.xmem_top.q_wire_1[4] = 0
+ xmem_pipeline.xmem_top.q_wire_1[5] = 0
+ xmem_pipeline.xmem_top.q_wire_1[6] = 0
+ xmem_pipeline.xmem_top.q_wire_1[7] = 0
+ xmem_pipeline.xmem_top.q_wire_1[8] = 0
+ xmem_pipeline.xmem_top.q_wire_1[9] = 0
+ xmem_pipeline.xmem_top.q_wire_1[10] = 0
+ xmem_pipeline.xmem_top.q_wire_1[11] = 0
+ xmem_pipeline.xmem_top.q_wire_1[12] = 0
+ xmem_pipeline.xmem_top.q_wire_1[13] = 0
+ xmem_pipeline.xmem_top.q_wire_1[14] = 0
+ xmem_pipeline.xmem_top.q_wire_1[15] = 0
+ xmem_pipeline.xmem_top.q_wire_2[0] = 0
+ xmem_pipeline.xmem_top.q_wire_2[1] = 0
+ xmem_pipeline.xmem_top.q_wire_2[2] = 0
+ xmem_pipeline.xmem_top.q_wire_2[3] = 0
+ xmem_pipeline.xmem_top.q_wire_2[4] = 0
+ xmem_pipeline.xmem_top.q_wire_2[5] = 0
+ xmem_pipeline.xmem_top.q_wire_2[6] = 0
+ xmem_pipeline.xmem_top.q_wire_2[7] = 0
+ xmem_pipeline.xmem_top.q_wire_2[8] = 0
+ xmem_pipeline.xmem_top.q_wire_2[9] = 0
+ xmem_pipeline.xmem_top.q_wire_2[10] = 0
+ xmem_pipeline.xmem_top.q_wire_2[11] = 0
+ xmem_pipeline.xmem_top.q_wire_2[12] = 0
+ xmem_pipeline.xmem_top.q_wire_2[13] = 0
+ xmem_pipeline.xmem_top.q_wire_2[14] = 0
+ xmem_pipeline.xmem_top.q_wire_2[15] = 0
+ xmem_pipeline.xmem_top.q_wire_3[0] = 0
+ xmem_pipeline.xmem_top.q_wire_3[1] = 0
+ xmem_pipeline.xmem_top.q_wire_3[2] = 0
+ xmem_pipeline.xmem_top.q_wire_3[3] = 0
+ xmem_pipeline.xmem_top.q_wire_3[4] = 0
+ xmem_pipeline.xmem_top.q_wire_3[5] = 0
+ xmem_pipeline.xmem_top.q_wire_3[6] = 0
+ xmem_pipeline.xmem_top.q_wire_3[7] = 0
+ xmem_pipeline.xmem_top.q_wire_3[8] = 0
+ xmem_pipeline.xmem_top.q_wire_3[9] = 0
+ xmem_pipeline.xmem_top.q_wire_3[10] = 0
+ xmem_pipeline.xmem_top.q_wire_3[11] = 0
+ xmem_pipeline.xmem_top.q_wire_3[12] = 0
+ xmem_pipeline.xmem_top.q_wire_3[13] = 0
+ xmem_pipeline.xmem_top.q_wire_3[14] = 0
+ xmem_pipeline.xmem_top.q_wire_3[15] = 0
